#include <cmath>
#include "renderer_canvas.h"

namespace {

struct Glyph {
    char c;
    unsigned char rows[7];
};

const Glyph glyphs[] = {
    {' ', {0x00,0x00,0x00,0x00,0x00,0x00,0x00}},
    {'!', {0x04,0x04,0x04,0x04,0x04,0x00,0x04}},
    {'.', {0x00,0x00,0x00,0x00,0x00,0x0C,0x0C}},
    {',', {0x00,0x00,0x00,0x00,0x0C,0x04,0x08}},
    {':', {0x00,0x0C,0x0C,0x00,0x0C,0x0C,0x00}},
    {'-', {0x00,0x00,0x00,0x1E,0x00,0x00,0x00}},
    {'+', {0x00,0x04,0x04,0x1F,0x04,0x04,0x00}},
    {'(', {0x02,0x04,0x08,0x08,0x08,0x04,0x02}},
    {')', {0x08,0x04,0x02,0x02,0x02,0x04,0x08}},
    {'/', {0x01,0x02,0x02,0x04,0x08,0x08,0x10}},
    {'0', {0x0E,0x11,0x13,0x15,0x19,0x11,0x0E}},
    {'1', {0x04,0x0C,0x04,0x04,0x04,0x04,0x0E}},
    {'2', {0x0E,0x11,0x01,0x02,0x04,0x08,0x1F}},
    {'3', {0x1F,0x02,0x04,0x02,0x01,0x11,0x0E}},
    {'4', {0x02,0x06,0x0A,0x12,0x1F,0x02,0x02}},
    {'5', {0x1F,0x10,0x1E,0x01,0x01,0x11,0x0E}},
    {'6', {0x06,0x08,0x10,0x1E,0x11,0x11,0x0E}},
    {'7', {0x1F,0x01,0x02,0x04,0x08,0x08,0x08}},
    {'8', {0x0E,0x11,0x11,0x0E,0x11,0x11,0x0E}},
    {'9', {0x0E,0x11,0x11,0x0F,0x01,0x02,0x0C}},
    {'A', {0x0E,0x11,0x11,0x1F,0x11,0x11,0x11}},
    {'B', {0x1E,0x11,0x11,0x1E,0x11,0x11,0x1E}},
    {'C', {0x0E,0x11,0x10,0x10,0x10,0x11,0x0E}},
    {'D', {0x1E,0x11,0x11,0x11,0x11,0x11,0x1E}},
    {'E', {0x1F,0x10,0x10,0x1E,0x10,0x10,0x1F}},
    {'F', {0x1F,0x10,0x10,0x1E,0x10,0x10,0x10}},
    {'G', {0x0E,0x11,0x10,0x17,0x11,0x11,0x0F}},
    {'H', {0x11,0x11,0x11,0x1F,0x11,0x11,0x11}},
    {'I', {0x0E,0x04,0x04,0x04,0x04,0x04,0x0E}},
    {'J', {0x07,0x02,0x02,0x02,0x02,0x12,0x0C}},
    {'K', {0x11,0x12,0x14,0x18,0x14,0x12,0x11}},
    {'L', {0x10,0x10,0x10,0x10,0x10,0x10,0x1F}},
    {'M', {0x11,0x1B,0x15,0x15,0x11,0x11,0x11}},
    {'N', {0x11,0x19,0x15,0x13,0x11,0x11,0x11}},
    {'O', {0x0E,0x11,0x11,0x11,0x11,0x11,0x0E}},
    {'P', {0x1E,0x11,0x11,0x1E,0x10,0x10,0x10}},
    {'Q', {0x0E,0x11,0x11,0x11,0x15,0x12,0x0D}},
    {'R', {0x1E,0x11,0x11,0x1E,0x14,0x12,0x11}},
    {'S', {0x0F,0x10,0x10,0x0E,0x01,0x01,0x1E}},
    {'T', {0x1F,0x04,0x04,0x04,0x04,0x04,0x04}},
    {'U', {0x11,0x11,0x11,0x11,0x11,0x11,0x0E}},
    {'V', {0x11,0x11,0x11,0x11,0x11,0x0A,0x04}},
    {'W', {0x11,0x11,0x11,0x15,0x15,0x15,0x0A}},
    {'X', {0x11,0x11,0x0A,0x04,0x0A,0x11,0x11}},
    {'Y', {0x11,0x11,0x0A,0x04,0x04,0x04,0x04}},
    {'Z', {0x1F,0x01,0x02,0x04,0x08,0x10,0x1F}}
};

const unsigned char *findGlyph(char c)
{
    for (int i = 0; i < (int)(sizeof(glyphs) / sizeof(glyphs[0])); i++) {
        if (glyphs[i].c == c) return glyphs[i].rows;
    }
    return glyphs[0].rows;
}

} // namespace

void RendererCanvas::line(float x0, float y0, float x1, float y1)
{
    int x = (int)roundf(x0), y = (int)roundf(y0);
    int xe = (int)roundf(x1), ye = (int)roundf(y1);

    if (x == xe) {
        int step = y < ye ? 1 : -1;
        for (int cy = y; cy != ye + step; cy += step)
            pixel((float)x, (float)cy);
        return;
    }
    if (y == ye) {
        int step = x < xe ? 1 : -1;
        for (int cx = x; cx != xe + step; cx += step)
            pixel((float)cx, (float)y);
        return;
    }

    int dx = abs(xe - x), sx = x < xe ? 1 : -1;
    int dy = -abs(ye - y), sy = y < ye ? 1 : -1;
    int err = dx + dy;

    for (;;) {
        pixel((float)x, (float)y);
        if (x == xe && y == ye) break;
        int e2 = 2 * err;
        if (e2 >= dy) { err += dy; x += sx; }
        if (e2 <= dx) { err += dx; y += sy; }
    }
}

void RendererCanvas::rect(float x, float y, float w, float h)
{
    int ix = (int)roundf(x), iy = (int)roundf(y);
    int iw = (int)roundf(w), ih = (int)roundf(h);
    for (int row = iy; row < iy + ih; row++) {
        for (int col = ix; col < ix + iw; col++) {
            pixel((float)col, (float)row);
        }
    }
}

void RendererCanvas::circle(float cx, float cy, float r)
{
    int xc = (int)roundf(cx), yc = (int)roundf(cy), rr = (int)roundf(r);
    int x = 0, y = rr, d = 1 - rr;
    while (x <= y) {
        pixel((float)(xc + x), (float)(yc + y));
        pixel((float)(xc - x), (float)(yc + y));
        pixel((float)(xc + x), (float)(yc - y));
        pixel((float)(xc - x), (float)(yc - y));
        pixel((float)(xc + y), (float)(yc + x));
        pixel((float)(xc - y), (float)(yc + x));
        pixel((float)(xc + y), (float)(yc - x));
        pixel((float)(xc - y), (float)(yc - x));
        if (d < 0) d += 2 * x + 3;
        else { d += 2 * (x - y) + 5; y--; }
        x++;
    }
}

void RendererCanvas::text(float x, float y, const char *s)
{
    int cx = (int)roundf(x);
    int cy = (int)roundf(y);
    for (const char *p = s; *p; p++) {
        const unsigned char *g = findGlyph(*p);
        for (int row = 0; row < 7; row++) {
            unsigned char b = g[row];
            for (int col = 0; col < 5; col++) {
                if (b & (1 << (4 - col))) pixel((float)(cx + col), (float)(cy + row));
            }
        }
        cx += 6;
    }
}
